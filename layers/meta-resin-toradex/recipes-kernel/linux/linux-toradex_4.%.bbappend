FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

inherit kernel-resin
